# Keil uVision project CoreRobot.uvproj, settings and files
target CoreRobot (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: CoreRobot +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Code\Common;.\Code;.\Code\BSP;.\Code\N76E003_HW
  group App
    ./Code/: mainapp.c motor.c voltage.c
    ./: protocol.c
  group Common
    ./Code/Common/: Common.c Delay.c
  group Startup
    ./Code/Common/: STARTUP_PORDIS.A51
  group BSP
    ./Code/BSP/: Board.c
  group HW
    ./Code/N76E003_HW/: GPIO.c Timer.c UART.c PWM.c
    ./Code/: LED.c
    ./: ADC.c
